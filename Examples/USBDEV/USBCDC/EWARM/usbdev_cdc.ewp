# IAR project usbdev_cdc.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe188, Pe186, Pe068
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx; ..\..\..\..\Drivers\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: USBHID.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\common\ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__=1; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx\startup\iar; ..\..\..\..\Drivers\include
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\common\ldscript_iram_iar.ld
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Main
    ../: cdcuser.c serial.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Readme
    ../: Abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/iar/: startup_LPC17xx.s
