# IAR project dac_wavegenerate.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx\startup\iar; ..\..\..\..\Drivers\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: dac_wavegenerate.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\common\ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__=1; __BUILD_WITH_EXAMPLE__=1
  OBJCOPY.OOCOutputFile: dac_wavegenerate.srec
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\common\ldscript_iram_iar.ld
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_gpdma.c lpc17xx_pinsel.c lpc17xx_uart.c
  group Main
    ../: dac_wave_generate.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/iar/: startup_LPC17xx.s
